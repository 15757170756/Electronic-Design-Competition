<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM32F429_439xx</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>STM32F427_437xx</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>STM32F40_41xxx</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>STM32F401xx</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\Include\core_cm4.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\Include\core_cm4_simd.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\system_stm32f4xx.c</name>
    </file>
  </group>
  <group>
    <name>Doc</name>
    <file>
      <name>$PROJ_DIR$\readme.txt</name>
    </file>
  </group>
  <group>
    <name>DSP</name>
  </group>
  <group>
    <name>EWARM</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\startup_stm32f401xx.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\startup_stm32f40_41xxx.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\startup_stm32f427_437xx.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Source\Templates\iar\startup_stm32f429_439xx.s</name>
    </file>
  </group>
  <group>
    <name>LNQ</name>
    <group>
      <name>ADC</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\src\AD.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\AD.h</name>
      </file>
    </group>
    <group>
      <name>common</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\src\common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\common.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\src\malloc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\malloc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\src\PINGPANG.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\PINGPANG.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\Sequeue.h</name>
      </file>
    </group>
    <group>
      <name>CPP</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\cpp\NumBar_CPP.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\cpp\NumBar_CPP.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\cpp\SelectBar_L.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\cpp\SelectBar_L.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\cpp\String_L.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\cpp\String_L.h</name>
      </file>
    </group>
    <group>
      <name>DAC</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\src\DA.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\DA.h</name>
      </file>
    </group>
    <group>
      <name>EXIT</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\src\exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\exti.h</name>
      </file>
    </group>
    <group>
      <name>LCD</name>
      <group>
        <name>Curve</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\src\LCD_Curve.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\LCD_Curve.h</name>
        </file>
      </group>
      <group>
        <name>String</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\src\LCD_String.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\LCD_String.h</name>
        </file>
      </group>
      <group>
        <name>Tools</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\src\LCD_Tools.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\LCD_Tools.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\src\NumBar.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\NumBar.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\src\SelectBar.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\SelectBar.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\src\SelectItem.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\SelectItem.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\src\FONT.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\FONT.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\src\LCD.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\LCD.h</name>
      </file>
    </group>
    <group>
      <name>NRF2401</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\src\NRF2401.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\NRF2401.h</name>
      </file>
    </group>
    <group>
      <name>SPI</name>
      <group>
        <name>ADS1220</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\src\ADS1220.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\ADS1220.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\src\SPI.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\SPI.h</name>
      </file>
    </group>
    <group>
      <name>Timer</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\src\Timer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\Timer.h</name>
      </file>
    </group>
    <group>
      <name>USART</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\src\USART.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\USART.h</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\LNQ\inc\GPIO.h</name>
    </file>
  </group>
  <group>
    <name>STM32F4xx_StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_aes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_des.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_cryp_tdes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dcmi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_dma2d.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_md5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_hash_sha1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_ltdc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rng.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sai.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\src\stm32f4xx_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <file>
      <name>$PROJ_DIR$\..\Data.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Data.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Freq.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Freq.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Impluse.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Impluse.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\main.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\main.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Span.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\Span.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\stm32f4xx_it.c</name>
    </file>
  </group>
</project>


